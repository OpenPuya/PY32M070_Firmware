# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: PY32M070xB Puya
  pack: Puya.PY32Mxxx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32M070xB,USE_FULL_LL_DRIVER
  c include: ..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\PY32M070_HAL_Driver\Inc;..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32M070\Include;..\..\..\..\..\..\Drivers\BSP\PY32M070xx_Start_Kit
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32m070.c
    ./: startup_py32m070xx.s
  group Application/User
    ../Src/: main.c py32m070_it.c
  group BSP/py32m070xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32M070xx_Start_Kit/: py32m070xx_ll_Start_Kit.c
  group Drivers/PY32M070_HAL_Driver
    ../../../../../../Drivers/PY32M070_HAL_Driver/Src/: py32m070_ll_utils.c py32m070_ll_spi.c py32m070_ll_gpio.c py32m070_ll_rcc.c py32m070_ll_dma.c
  group Doc
    ../: readme.txt
